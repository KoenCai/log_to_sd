# Keil uVision project uart_event.uvprojx, settings and files
target IK-52840DK (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00800000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: nrf52840_qiaa +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_PCA10056 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\config;..\..\components;..\..\components\boards;..\..\modules\nrfx;..\..\modules\nrfx\hal;..\..\modules\nrfx\mdk;..\..\modules\nrfx\drivers\include;..\..\integration\nrfx;..\..\integration\nrfx\legacy;..\..\components\drivers_nrf\nrf_soc_nosd;..\..\components\libraries\delay;..\..\components\libraries\util;..\..\components\libraries\strerror;..\..\components\libraries\log;..\..\components\libraries\log\src;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\memobj;..\..\components\libraries\balloc;..\..\components\libraries\ringbuf;..\..\components\libraries\atomic;..\..\components\libraries\uart;..\..\components\libraries\fifo;..\..\external\fprintf;..\..\external\segger_rtt;..\..\app;..\..\external\fatfs\src;..\..\external\fatfs\port;..\..\components\libraries\block_dev;..\..\components\libraries\block_dev\sdc;..\..\components\libraries\sdcard;..\..\components\libraries\atomic_fifo;..\..\components\libraries\sortlist;..\..\components\libraries\timer;..\..\external\protothreads\pt-1.4;..\..\external\protothreads
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
  link misc: --diag_suppress 6330
  group Application
    ../../app/: main.c ring_buffer.c SDcardRW.c Board_Config.h
    ../config/: sdk_config.h
  group Board Definition
    ../../components/boards/: boards.c
    ../../app/: rtc.c led.c key.c UartE.c
  group Fatfs
    ../../external/fatfs/src/: ff.c ffconf.h
    ../../external/fatfs/port/: diskio_blkdev.c
  group nRF_Drivers
    ../../modules/nrfx/soc/: nrfx_atomic.c
    ../../integration/nrfx/legacy/: nrf_drv_uart.c nrf_drv_spi.c nrf_drv_clock.c
    ../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../modules/nrfx/drivers/src/: nrfx_uart.c nrfx_uarte.c nrfx_spi.c nrfx_spim.c nrfx_clock.c nrfx_rtc.c nrfx_power_clock.c
  group nRF_Libraries
    ../../components/libraries/util/: app_error.c nrf_assert.c app_util_platform.c app_error_handler_keil.c app_error_weak.c
    ../../components/libraries/strerror/: nrf_strerror.c
    ../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../components/libraries/memobj/: nrf_memobj.c
    ../../components/libraries/atomic/: nrf_atomic.c
    ../../components/libraries/balloc/: nrf_balloc.c
    ../../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../components/libraries/fifo/: app_fifo.c
    ../../components/libraries/sdcard/: app_sdcard.c
    ../../components/libraries/block_dev/sdc/: nrf_block_dev_sdc.c
  group nRF_Log
    ../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 5.3.0, Device:Startup 8.35.0
